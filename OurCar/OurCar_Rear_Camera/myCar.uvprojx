# Keil uVision project myCar.uvprojx, settings and files
target myCar (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: myCar
  c flags: Optim=1 uC99=1 wLevel=2
  c define: MK60D10
  c include: .\app;.\devices;.\drivers\inc;.\fat32;.\usmart
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group app
    ./app/: ctrl.c Debug.c filter.c main.c umc.c Get_Bacon.c can_communication.c
  group devices
    ./devices/: anglesensor.c BatteryMon.c bluetooth.c encoder.c KEY.c motor.c oled.c led.c Eagle.c sccb.c servo.c IR.c ST7735R.c ccd.c
  group drivers
    ./drivers/src/: adc.c common.c dma.c ftm.c gpio.c i2c.c lptmr.c pit.c sd.c systick.c uart.c spi.c can.c
    ./devices/: adns9800.c
  group fat32
    ./fat32/: deviceio.c znfat.c
  group usmart
    ./usmart/: usmart.c usmart_config.c usmart_str.c
  group ::Device
    RTE/Device/MK60DN512xxx10/: startup_MK60D10.s system_MK60D10.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
